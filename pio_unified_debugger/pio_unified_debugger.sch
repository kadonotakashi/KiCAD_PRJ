File: pio_unified_debugger/pio_unified_debugger.sch (KiCad schematic (older format))
At the start: 8 parts

Commit message: add platformio debugger
Other:
- moved on the sheet: J?, Q?, R?, U?
